** AVCLAN Sniffer PAGE1 **
*
* Electronics Workbench
*
* This file was created by:
*   Multisim to SPICE netlist routine
*
* Generated by: dbroad
* Friday, November 24 16:37:34, 2006
*
*

VDDVDD  VDD 0 dc 5

VCCVCC  VCC 0 dc 12

cC1 0 VCC 1.000e-005

cC7 0 VDD 2.200e-005

xU6 VCC VDD 0 LM2940T_5__VOLTAGE_REGULATOR__1

.SUBCKT LM2940T_5__VOLTAGE_REGULATOR__1 3 1 2
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
* Model generated on Sep  8, 97
* MODEL FORMAT: SPICE3
*Rev. Date: Dec. 20, 1994
*Positive Fixed Regulator
*External Node Designations
*node 1: VREG (OUTPUT)
*node 2: Ground (Common)
*node 3: Line Voltage
ECCX 131 2 135 2 1.0
VXX 133 2 DC 0
FSET6 2 135 VSENS2 1
FPP 3 2 VXX 1.0
R_YY 31 2 1e6
R_XX 15 2 1e8
R_ZZ 36 2 1e6
R_QQ 65 2 1e8
RXX 1 2 1e8
VSENS1 10 1 DC 0
ISET 2 15 DC 1e-3
DON1 15 16 DMOD1
VSENS2 16 19 DC 0
DON2 15 17 DMOD1
EON2 18 2 3 2 1
FYY 3 2 VSENS1 1
DON3 15 27 DMOD1
VDROP3 28 27 DC 2
EON3 28 2 3 2 4
ELINE 13 42 66 2 1
FSET2 2 36 VSENS2 1
DSC1 36 35 DMOD1
RCL1 36 37 10
DSC2 37 38 DMOD1
ESCCON 38 39 30 2 1
VSCCON 39 40 DC 0
FSC 19 2 VSCCON 1
FSET3 2 31 VSENS2 1
DOV1 31 32 DMOD1
EOV1 32 2 3 1 1
DOV2 31 33 DMOD1
ISET4 2 30 DC 1e-3
ELOAD 41 2 77 2 -1
ERIPPLE 42 41 72 2 1
EREF 12 13 19 2 1
E3 52 2 3 2 1
CBYPS 54 2 0.001
VORB 54 60 DC 0
RB 60 2 1e3
RBR 72 2 1000
CBS2 52 71 1
RSTEP 77 2 1
FRB 2 65 VORB 1
DRB2 65 67 DMOD1
VXRB 67 68 DC -1
EXRB 68 2 1 2 1
DRB1 65 66 DMOD1
RB1 66 2 1000
.MODEL DMOD1 D
*-- DMOD1 DEFAULT PARAMETERS
*IS=1e-14 RS=0 N=1 TT=0 CJO=0
*VJ=1 M=0.5 EG=1.11 XTI=3 FC=0.5
*KF=0 AF=1 BV=inf IBV=1e-3 TNOM=27
EXX 132 131 3 131 3.33333e-07
RST6 135 2 10000
RIQX 133 132 RQIX 333.333
.MODEL RQIX R TC1=-0.005
RSET 19 2 RSET 5000
.MODEL RSET R TC1=0 TC2=0
RS1 10 12 0.0368
VDROPX 18 17 -0.13
HSENSE1 35 2 VSENS1 5.26316
RISC 30 2 RISC 10000
.MODEL RISC R TC1=0
ROV 34 2 25800
VOV 33 34 5.2
EOV2 2 40 34 2 0.183599
FIQD 3 2 VSENS1 0
RY 52 54 985222
RA 72 73 9020.4
RYR 71 72 3.98007e+06
CRA 52 73 3.98975e-11
HSTEP 76 2 VSENS1 0.368
CSTEP 76 77 5.30516e-06
.ENDS lm2940t_5

** AVCLAN Sniffer PAGE2 **
*
* Electronics Workbench
*
* This file was created by:
*   Multisim to SPICE netlist routine
*
* Generated by: dbroad
* Friday, November 24 16:37:34, 2006
*
*

cC14 0 50 2.2E-11

cC13 0 51 2.2E-11

xX1 51 50 CRYSTAL_HC-49/U_15MHZ__CRYSTAL__1

rR12 VDD 42 1.000e+004

cC12 9 0 1.0E-7

rR11 43 0 1.000e+003

rR10 37 41 1.000e+006

rR9 VDD 41 3.0k

rR8 0 37 1.000e+004

rR7 39 37 180

rR6 38 40 180

rR5 38 39 120

xU10_A 37 40  VDD 0 41 LM139A__COMPARATOR__1

.SUBCKT CRYSTAL_HC-49/U_15MHZ__CRYSTAL__1 1 2
* EWB Version 4 - CRYSTAL Model
* LS= 0.005 CS= 2.2e-014 RS= 10 CO= 5e-012
    LS   1  3 0.005
    CS   3  4 2.2e-014
    RS   4  2 10
    CO   1  2 5e-012
.ENDS

* LM139A VOLTAGE COMPARATOR "MACROMODEL" SUBCIRCUIT
* CREATED USING PARTS VERSION 4.03 ON 03/07/90 AT 14:17
* REV (N/A)
* CONNECTIONS:   NON-INVERTING INPUT
*                | INVERTING INPUT
*                | | POSITIVE POWER SUPPLY
*                | | | NEGATIVE POWER SUPPLY
*                | | | | OPEN COLLECTOR OUTPUT
*                | | | | |
.SUBCKT LM139A__COMPARATOR__1   1 2 3 4 5
*
  F1    9  3 V1 1
  IEE   3  7 DC 100.0E-6
  VI1  21  1 DC .75
  VI2  22  2 DC .75
  Q1    9 21  7 QIN
  Q2    8 22  7 QIN
  Q3    9  8  4 QMO
  Q4    8  8  4 QMI
.MODEL QIN PNP(IS=800.0E-18 BF=2.000E3)
.MODEL QMI NPN(IS=800.0E-18 BF=1002)
.MODEL QMO NPN(IS=800.0E-18 BF=1000 CJC=1E-15 TR=807.4E-9)
  E1   10  4  9  4  1
  V1   10 11 DC 0
  Q5    5 11  4 QOC
.MODEL QOC NPN(IS=800.0E-18 BF=20.29E3 CJC=1E-15 TF=942.6E-12 TR=543.8E-9)
  DP    4  3 DX
  RP 3  4 46.3E3
.MODEL DX  D(IS=800.0E-18)
.ENDS

** AVCLAN Sniffer PAGE3 **
*
* Electronics Workbench
*
* This file was created by:
*   Multisim to SPICE netlist routine
*
* Generated by: dbroad
* Friday, November 24 16:37:34, 2006
*
*

cC5 55 0 1.000e-006

cC6 VDD 56 1.000e-006

cC3 53 54 1.000e-006

cC4 49 52 1.000e-006
